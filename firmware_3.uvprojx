# Keil uVision project firmware_3.uvprojx, settings and files
target firmware_3 (6070000::V6.7::.\ARMCLANG)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: firmware_3
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: TARGET_STM32L432xC DEVICE_ANALOGOUT=1 MBED_BUILD_TIMESTAMP=1580251295.8509626 MBED_ROM_START=0x8000000 TARGET_LIKE_CORTEX_M4 __MBED_CMSIS_RTOS_CM STM32L432xx TOOLCHAIN_ARM_STD COMPONENT_NSPE=1 DEVICE_INTERRUPTIN=1 TARGET_LIKE_MBED __MBED__=1 MBED_ROM_SIZE=0x40000 TARGET_RELEASE DEVICE_RESET_REASON=1 DEVICE_ANALOGIN=1 DEVICE_I2CSLAVE=1 COMPONENT_PSA_SRV_EMUL=1 __ASSERT_MSG __CMSIS_RTOS DEVICE_PORTOUT=1 TARGET_STM32L4 TRANSACTION_QUEUE_SIZE_SPI=2 DEVICE_PORTIN=1 MBED_TICKLESS DEVICE_SPI=1 TARGET_NUCLEO_L432KC COMPONENT_PSA_SRV_IMPL=1 DEVICE_SLEEP=1 DEVICE_CRC=1 TARGET_RTOS_M4_M7 ARM_MATH_CM4 USE_HAL_DRIVER DEVICE_TRNG=1 EXTRA_IDLE_STACK_REQUIRED TARGET_STM32L432KC __FPU_PRESENT=1 DEVICE_SPI_ASYNCH=1 TOOLCHAIN_ARMC6 DEVICE_RTC=1 MBED_RAM_SIZE=0xc000 USE_FULL_LL_DRIVER MBED_RAM_START=0x20000000 TARGET_STM DEVICE_SERIAL=1 DEVICE_STDIO_MESSAGES=1 DEVICE_WATCHDOG=1 DEVICE_USTICKER=1 DEVICE_LPTICKER=1 MBED_RAM1_SIZE=0x4000 __CORTEX_M4 MULADDC_CANNOT_USE_R7 MBED_RAM1_START=0x10000000 DEVICE_CAN=1 TARGET_CORTEX_M DEVICE_PORTINOUT=1 DEVICE_SERIAL_FC=1 DEVICE_I2C_ASYNCH=1 DEVICE_I2C=1 DEVICE_PWMOUT=1 TARGET_M4 DEVICE_SERIAL_ASYNCH=1 DEVICE_FLASH=1 DEVICE_SPISLAVE=1 TOOLCHAIN_ARM TARGET_NAME=NUCLEO_L432KC TARGET_FAMILY_STM32 MBED_TRAP_ERRORS_ENABLED=1 DEVICE_MPU=1 TARGET_CORTEX
  c misc: -mfloat-abi=hard -mthumb -Wno-deprecated-register --target=arm-arm-none-eabi -Wno-armcc-pragma-anon-unions -fshort-wchar -c -Wno-reserved-user-defined-literal -fno-rtti -fshort-enums -Wno-armcc-pragma-push-pop -mcpu=cortex-m4 -fdata-sections -mfpu=fpv4-sp-d16 -fno-exceptions -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;DHTxx;STRAIN_GAUGE;STRAIN_GAUGE/HX711;mbed;mbed/TARGET_NUCLEO_L432KC/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform;sigfox
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__FPU_PRESENT=1,-DUSE_FULL_LL_DRIVER,-DMBED_TICKLESS,-DARM_MATH_CM4,-DSTM32L432xx,-D__MBED_CMSIS_RTOS_CM,-DEXTRA_IDLE_STACK_REQUIRED,-DUSE_HAL_DRIVER,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .link_script.sct
  link misc: --legacyalign --predefine="-DMBED_RAM_SIZE=0xc000" --cpu=Cortex-M4 --predefine="-DMBED_ROM_SIZE=0x40000" --keep=os_cb_sections --predefine="-DMBED_RAM1_START=0x10000000" --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM1_SIZE=0x4000" --any_contingency --show_full_path
  group DHTxx
    DHTxx/: DHTxx.cpp DHTxx.h
  group firmware_3
    ./: app.cpp app.h main.cpp mapping.h mbed_config.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_L432KC/TOOLCHAIN_ARM_STD/: analogin_api.o analogin_device.o analogout_api.o analogout_device.o arm_math.h can_api.o can_device.h cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_version.h common_objects.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h device.h except.o flash_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.h gpio_irq_device.o gpio_object.h hal_tick_overrides.o i2c_api.o i2c_device.h l4_retarget.o lp_ticker.o mbed.ar mbed_board.o mbed_cmsis_conf.h mbed_crc_api.o mbed_fault_handler.h mbed_fault_handler.o mbed_overrides.o mbed_retarget.o mbed_rtx.h mbed_sdk_boot.o mbed_tz_context.o mpu_armv7.h mpu_armv8.h nvic_addr.h objects.h PeripheralNames.h PeripheralPins.h PeripheralPins.o pin_device.h pinmap.o PinNames.h PinNamesTypes.h port_api.o PortNames.h pwmout_api.o pwmout_device.h pwmout_device.o qspi_api.o rtc_api.o rtc_api_hal.h RTE_Components.h serial_api.o serial_api_hal.h serial_device.o sleep.o spi_api.o spi_device.h startup_stm32l432xx.o stm32_assert.h stm32_hal_legacy.h stm32l432xx.h stm32l4xx.h stm32l4xx_hal.h stm32l4xx_hal.o stm32l4xx_hal_adc.h stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.h stm32l4xx_hal_adc_ex.o stm32l4xx_hal_can.h stm32l4xx_hal_can.o stm32l4xx_hal_can_legacy.h stm32l4xx_hal_can_legacy.o stm32l4xx_hal_comp.h stm32l4xx_hal_comp.o stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.h stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.h stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.h stm32l4xx_hal_crc_ex.o stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp.o stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_cryp_ex.o stm32l4xx_hal_dac.h stm32l4xx_hal_dac.o stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dac_ex.o stm32l4xx_hal_dcmi.h stm32l4xx_hal_dcmi.o stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dfsdm.o stm32l4xx_hal_dfsdm_ex.h stm32l4xx_hal_dfsdm_ex.o stm32l4xx_hal_dma.h stm32l4xx_hal_dma.o stm32l4xx_hal_dma2d.h stm32l4xx_hal_dma2d.o stm32l4xx_hal_dma_ex.h stm32l4xx_hal_dma_ex.o stm32l4xx_hal_dsi.h stm32l4xx_hal_dsi.o stm32l4xx_hal_firewall.h stm32l4xx_hal_firewall.o stm32l4xx_hal_flash.h stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gfxmmu.h stm32l4xx_hal_gfxmmu.o stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio.o stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hash.h stm32l4xx_hal_hash.o stm32l4xx_hal_hash_ex.h stm32l4xx_hal_hash_ex.o stm32l4xx_hal_hcd.h stm32l4xx_hal_hcd.o stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_irda.h stm32l4xx_hal_irda.o stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.h stm32l4xx_hal_iwdg.o stm32l4xx_hal_lcd.h stm32l4xx_hal_lcd.o stm32l4xx_hal_lptim.h stm32l4xx_hal_lptim.o stm32l4xx_hal_ltdc.h stm32l4xx_hal_ltdc.o stm32l4xx_hal_ltdc_ex.h stm32l4xx_hal_ltdc_ex.o stm32l4xx_hal_nand.h stm32l4xx_hal_nand.o stm32l4xx_hal_nor.h stm32l4xx_hal_nor.o stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp.o stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_opamp_ex.o stm32l4xx_hal_ospi.h stm32l4xx_hal_ospi.o stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_qspi.h stm32l4xx_hal_qspi.o stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rng.h stm32l4xx_hal_rng.o stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sai.h stm32l4xx_hal_sai.o stm32l4xx_hal_sai_ex.h stm32l4xx_hal_sai_ex.o stm32l4xx_hal_sd.h stm32l4xx_hal_sd.o stm32l4xx_hal_sd_ex.h stm32l4xx_hal_sd_ex.o stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard.o stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smartcard_ex.o stm32l4xx_hal_smbus.h stm32l4xx_hal_smbus.o stm32l4xx_hal_spi.h stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.h stm32l4xx_hal_spi_ex.o stm32l4xx_hal_sram.h stm32l4xx_hal_sram.o stm32l4xx_hal_swpmi.h stm32l4xx_hal_swpmi.o stm32l4xx_hal_tim.h stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tim_ex.o stm32l4xx_hal_tsc.h stm32l4xx_hal_tsc.o stm32l4xx_hal_uart.h stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.h stm32l4xx_hal_uart_ex.o stm32l4xx_hal_usart.h stm32l4xx_hal_usart.o stm32l4xx_hal_usart_ex.h stm32l4xx_hal_usart_ex.o stm32l4xx_hal_wwdg.h stm32l4xx_hal_wwdg.o stm32l4xx_ll_adc.h stm32l4xx_ll_adc.o stm32l4xx_ll_bus.h stm32l4xx_ll_comp.h stm32l4xx_ll_comp.o stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.h stm32l4xx_ll_crc.o stm32l4xx_ll_crs.h stm32l4xx_ll_crs.o stm32l4xx_ll_dac.h stm32l4xx_ll_dac.o stm32l4xx_ll_dma.h stm32l4xx_ll_dma.o stm32l4xx_ll_dma2d.h stm32l4xx_ll_dma2d.o stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.h stm32l4xx_ll_exti.o stm32l4xx_ll_fmc.h stm32l4xx_ll_fmc.o stm32l4xx_ll_gpio.h stm32l4xx_ll_gpio.o stm32l4xx_ll_i2c.h stm32l4xx_ll_i2c.o stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.h stm32l4xx_ll_lptim.o stm32l4xx_ll_lpuart.h stm32l4xx_ll_lpuart.o stm32l4xx_ll_opamp.h stm32l4xx_ll_opamp.o stm32l4xx_ll_pwr.h stm32l4xx_ll_pwr.o stm32l4xx_ll_rcc.h stm32l4xx_ll_rcc.o stm32l4xx_ll_rng.h stm32l4xx_ll_rng.o stm32l4xx_ll_rtc.h stm32l4xx_ll_rtc.o stm32l4xx_ll_sdmmc.h stm32l4xx_ll_sdmmc.o stm32l4xx_ll_spi.h stm32l4xx_ll_spi.o stm32l4xx_ll_swpmi.h stm32l4xx_ll_swpmi.o stm32l4xx_ll_system.h stm32l4xx_ll_tim.h stm32l4xx_ll_tim.o stm32l4xx_ll_usart.h stm32l4xx_ll_usart.o stm32l4xx_ll_usb.h stm32l4xx_ll_usb.o stm32l4xx_ll_utils.h stm32l4xx_ll_utils.o stm32l4xx_ll_wwdg.h stm_spi_api.o system_clock.o system_stm32l4xx.h system_stm32l4xx.o trng_api.o tz_context.h us_ticker.o us_ticker_data.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h CThunkBase.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_crash_data_offsets.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/: mbed.h
  group sigfox
    sigfox/: sigfox.cpp sigfox.h
  group STRAIN_GAUGE
    STRAIN_GAUGE/HX711/: HX711.cpp HX711.h
    STRAIN_GAUGE/: STRAIN_GAUGE.cpp STRAIN_GAUGE.h test.cpp
